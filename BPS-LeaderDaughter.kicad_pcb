File: BPS-LeaderDaughter.kicad_pcb (KiCad board)
At the start: 2 copper layers, 96 parts, among them IC1 ADT7470ARQZ-REEL7, J1 DaughterConnector, J10 Conn_01x04, J11 Conn_01x04, J2 DaughterConnector, J3 ErrorLightConn, J4 Conn_01x04, J5 Conn_01x04, J6 Conn_01x04, J7 Conn_01x04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

Commit message: Fan layout updated
Parts:
- added C16: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (111.7, -53.7)
- added C17: 10uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (111.7, -50.7)
- added C18: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (129.0, -68.8)
- added C19: 10uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (129.0, -65.7)
- added C20: 100nF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (111.7, -68.8)
- added C21: 10uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (111.7, -65.7)
- added C22: 1uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (111.7, -47.7)
- added C23: 1uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (129.0, -62.7)
- added C24: 1uF, Capacitor_SMD:C_0805_2012Metric, F.Cu at (111.7, -62.7)
- added D20: BAS70-04, Package_TO_SOT_SMD:SOT-23, F.Cu at (116.4, -61.6)
- added D21: V2F22HM, UTSVT_Passive:V2F22HM, F.Cu at (121.8, -62.0)
- added D25: Green, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (120.8, -47.2)
- added D26: Green, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (133.7, -62.3)
- added D27: Green, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (121.2, -58.7)
- added J12: ErrorLightConn, UTSVT_Connectors:Molex_MicroFit3.0_1x2xP3.00mm_PolarizingPeg_Vertical, F.Cu at (130.2, -51.6)
- added R1: 1k, Resistor_SMD:R_0805_2012Metric, F.Cu at (127.3, -46.5)
- added R4: 100k, Resistor_SMD:R_0805_2012Metric, F.Cu at (127.3, -43.5)
- added R41: 50, Resistor_SMD:R_0805_2012Metric, F.Cu at (116.1, -44.3)
- added R42: 50, Resistor_SMD:R_0805_2012Metric, F.Cu at (129.0, -59.8)
- added R43: 50, Resistor_SMD:R_0805_2012Metric, F.Cu at (111.7, -59.8)
- added R7: 5k, Resistor_SMD:R_0805_2012Metric, F.Cu at (116.1, -47.3)
- added U5: SI8261ABC-IS, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (118.2, -52.0)
- added U6: SI8261ABC-IS, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (135.5, -67.0)
- added U7: SI8261ABC-IS, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (118.2, -67.0)
- C1: value 100nF -> 1uF
- C2: value 10uF -> 1uF
- C3: value 1u -> 1uF
- C8: value 1uF -> 100nF
- C9: value 100nF -> 10uF
- D10, D13: value Green -> BAS70-04; footprint LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> Package_TO_SOT_SMD:SOT-23
- D6, D9: value BAS70-04 -> 1N4148WS; footprint Package_TO_SOT_SMD:SOT-23 -> Diode_SMD:D_SOD-323F
- D7: value Green -> 1N4148WS; footprint LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> Diode_SMD:D_SOD-323F
- D8: value V2F22HM -> 1N4148WS; footprint UTSVT_Passive:V2F22HM -> Diode_SMD:D_SOD-323F
- Q1: value VND5N07-E -> BUK9M23-80E; footprint Package_TO_SOT_SMD:TO-252-2 -> Package_TO_SOT_SMD:LFPAK33
- Q2, Q3, Q4: value BUK9M3R3-40HX -> BUK9M23-80E
- R11, R3: value 100k -> 5k
- R6, R9: value 10k -> 100k
- moved D8 279.9 mm to (262.8, 105.2), turned to 90 degrees
- moved C4 262.6 mm to (238.2, 91.2), turned to -90 degrees
- moved D7 255.1 mm to (262.8, 79.4), turned to 90 degrees
- moved D9 248.3 mm to (262.5, 135.2), turned to 90 degrees
- moved D6 240.1 mm to (262.8, 50.4), turned to 90 degrees
Connections:
- net Net-(J4-Pin_2) renamed /Fan Control/ORION_PWM
- C3 pad 2: Net-(J3-Pin_1) -> GNDPWR
- C4 pad 1: /HV+_Sense -> +3.3V
- C8 pad 1: /HV-_Sense -> +12V
- C8 pad 2: GND -> GNDPWR
- D10 pad 1: /HV- Contactor Driver/CONTACTOR_V- -> GND
- D10 pad 2: Net-(D10-A) -> +3.3V
- D11 pad 2: /HV- Contactor Driver/CONTACTOR_V- -> /HV+ Contactor Driver/CONTACTOR_V-
- D13 pad 1: /Array Contactor Driver/CONTACTOR_V- -> GND
- D13 pad 2: Net-(D13-A) -> +3.3V
- D14 pad 2: /Array Contactor Driver/CONTACTOR_V- -> /HV- Contactor Driver/CONTACTOR_V-
- D6 pad 1: GND -> +12V
- D6 pad 2: +5V -> /Fan Control/PWM1_OUT
- D7 pad 1: /HV+ Contactor Driver/CONTACTOR_V- -> +12V
- D7 pad 2: Net-(D7-A) -> /Fan Control/PWM2_OUT
- D8 pad 2: /HV+ Contactor Driver/CONTACTOR_V- -> /Fan Control/PWM3_OUT
- D9 pad 1: GND -> +12V
- D9 pad 2: +5V -> /Fan Control/PWM4_OUT
- IC1 pad 14: unconnected-(IC1-~{SMBALERT}-Pad14) -> /Fan Control/~{SMBALERT}
- Q1 pad 1: Net-(Q1-G) -> GNDPWR
- Q1 pad 2: Net-(J3-Pin_2) -> GNDPWR
- Q2 pad 4: /HV+ Contactor Driver/PWM_ISO -> /HV- Contactor Driver/PWM_ISO
- Q2 pad 5: /HV+ Contactor Driver/CONTACTOR_V- -> /HV- Contactor Driver/CONTACTOR_V-
- Q3 pad 4: /HV- Contactor Driver/PWM_ISO -> Net-(Q3-G)
- Q3 pad 5: /HV- Contactor Driver/CONTACTOR_V- -> Net-(J12-Pin_2)
- R11 pad 1: /Array Contactor Driver/PWM_ISO -> +12V
- R11 pad 2: GNDPWR -> Net-(D27-A)
- R2 pad 1: Net-(Q1-G) -> /Fault
- R2 pad 2: Net-(D1-A) -> Net-(U2-ANODE)
- R3 pad 1: Net-(Q1-G) -> +12V
- R3 pad 2: GNDPWR -> Net-(D26-A)
- R6 pad 1: +12V -> /HV- Contactor Driver/PWM_ISO
- R6 pad 2: Net-(D7-A) -> GNDPWR
- R9 pad 1: +12V -> /Array Contactor Driver/PWM_ISO
- R9 pad 2: Net-(D10-A) -> GNDPWR
- U2 pad 6: /HV+ Contactor Driver/PWM_ISO -> Net-(Q3-G)
- U2 pad 7: /HV+ Contactor Driver/PWM_ISO -> Net-(Q3-G)
Other:
- board text added: "1"
- board text added: "12V"
- board text added: "12V(OR 10)"
- board text added: "2"
- board text added: "3"
- board text added: "3 WIRE"
- board text added: "4"
- board text added: "4 WIRE"
- board text added: "BRIDGE"
- board text added: "FAN 1"
- board text added: "FAN 2"
- board text added: "FAN 3"
- board text added: "FAN 4"
- board text added: "GND"
- board text added: "GND(OR 12)"
- board text added: "ORION PWM"
- board text added: "PWM"
- board text added: "PWM(OR 24)"
- board text added: "TACH"
- board text added: "TACH(OR 9)"

Commit message: updated som connecters to match leadersom
Parts:
- added ?: , , F.Cu at (142.8, 121.2)
- added ?: , , F.Cu at (142.8, 80.8)
- moved J2 233.5 mm to (168.8, 107.8), turned to 90 degrees
- moved J1 232.1 mm to (168.8, 95.8), turned to 90 degrees
- moved J5 15.8 mm to (271.2, 53.8)
- moved D18 11.7 mm to (252.8, 118.6)
- moved D5 11.7 mm to (260.8, 118.6)
- moved D9 11.7 mm to (262.8, 123.6)
- moved Q8 11.7 mm to (257.5, 123.6)
- moved R22 11.7 mm to (254.2, 123.6)
- moved R23 11.7 mm to (260.8, 123.6)
- moved R30 11.7 mm to (254.8, 118.6)
- moved R31 11.7 mm to (256.8, 118.6)
- moved R32 11.7 mm to (258.8, 118.6)
- moved J8 11.7 mm to (271.0, 116.8)
- moved D15 11.2 mm to (252.8, 56.8)
- moved D2 11.2 mm to (260.8, 56.8)
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Connections:
- IC1 pad 14: /Fan Control/~{SMBALERT} -> /~{SMBALERT}
- J1 pad 1: +3.3V -> +12V
- J1 pad 11: unconnected-(J1-Pad11) -> +3.3V
- J1 pad 13: unconnected-(J1-Pad13) -> /SDA
- J1 pad 15: unconnected-(J1-Pad15) -> /SCL
- J1 pad 2: +3.3V -> +12V
- J1 pad 8: unconnected-(J1-Pad8) -> /~{SMBALERT}
- J1 pad 9: unconnected-(J1-Pad9) -> +3.3V
- J2 pad 1: +12V -> GND
- J2 pad 13: /SDA -> unconnected-(J2-Pad13)
- J2 pad 15: /SCL -> unconnected-(J2-Pad15)
- J2 pad 17: GND -> +3.3V
- J2 pad 18: GND -> +3.3V
- J2 pad 2: +12V -> GND
- J2 pad 3: GNDPWR -> GND
- J2 pad 4: GNDPWR -> GND

Commit message: strobe light layout
Parts:
- moved U2 216.8 mm to (7.00, 122.0)
- moved R1 205.4 mm to (15.8, 126.0), turned to 180 degrees
- moved J12 203.1 mm to (22.1, 120.2), turned to -90 degrees
- moved R4 200.7 mm to (16.9, 124.0), turned to 180 degrees
- moved C8 170.7 mm to (11.8, 121.2), turned to -90 degrees
- moved R2 170.6 mm to (2.25, 120.2), turned to -90 degrees
- moved C9 167.2 mm to (13.8, 121.2), turned to -90 degrees
- moved D1 165.3 mm to (12.8, 124.0)
- moved Q3 164.8 mm to (16.9, 120.8), turned to 90 degrees

Commit message: H+ Contacter layout idea
Parts:
- moved J9 197.4 mm to (61.2, 101.0), turned to -90 degrees
- moved R5 188.6 mm to (43.2, 103.8), turned to 90 degrees
- moved U5 177.1 mm to (32.5, 103.0)
- moved C16 172.4 mm to (37.2, 101.8), turned to -90 degrees
- moved R41 170.4 mm to (27.7, 101.3), turned to -90 degrees
- moved C17 168.8 mm to (39.2, 101.8), turned to -90 degrees
- moved C22 165.4 mm to (53.9, 107.2), turned to 180 degrees
- moved D25 164.4 mm to (54.5, 103.2), turned to 90 degrees
- moved R7 161.6 mm to (52.5, 101.3), turned to -90 degrees
- moved D11 145.9 mm to (50.2, 102.5), turned to -90 degrees
- moved C1 143.0 mm to (41.2, 101.8), turned to -90 degrees
- moved D10 142.2 mm to (54.0, 110.0)
- moved Q1 142.0 mm to (46.6, 103.9)
- moved J12 46.0 mm to (51.5, 85.0)
- moved R4 43.7 mm to (41.4, 87.8), turned to 90 degrees
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
Commit message: contactor and strobe layout
Parts:
- removed C10, C14, C6: 10uF, Capacitor_SMD:C_0805_2012Metric
- removed C11, C12, C15, C7: 1uF, Capacitor_SMD:C_0805_2012Metric
- removed C13, C5: 100nF, Capacitor_SMD:C_0805_2012Metric
- removed D12: BAS70-04, Package_TO_SOT_SMD:SOT-23
- removed J3: ErrorLightConn, UTSVT_Connectors:Molex_MicroFit3.0_1x2xP3.00mm_PolarizingPeg_Vertical
- removed R12: 10k, Resistor_SMD:R_0805_2012Metric
- removed R8: 100k, Resistor_SMD:R_0805_2012Metric
- removed U1, U3, U4: SI8261ABC-IS, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
- C22, C23, C24, R1, R41, R42, R43, R5, R6, R9: moved to B.Cu
- moved D14 206.3 mm to (113.5, 113.5), turned to 90 degrees
- moved R6 203.0 mm to (123.8, 108.8), turned to 180 degrees
- moved Q2 202.3 mm to (120.3, 109.0), turned to 180 degrees
- moved J11 195.6 mm to (107.7, 96.3), turned to 90 degrees
- moved D13 191.7 mm to (116.2, 109.0), turned to 180 degrees
- moved R11 186.7 mm to (121.8, 96.1), turned to 90 degrees
- moved C18 183.8 mm to (115.8, 114.6), turned to 90 degrees
- moved C19 180.7 mm to (117.8, 114.6), turned to 90 degrees
- moved Q4 178.6 mm to (120.4, 90.3), turned to 180 degrees
- moved U6 176.4 mm to (125.4, 109.0), turned to -90 degrees
- moved D26 174.6 mm to (120.8, 111.8)
- moved C23 171.3 mm to (115.3, 108.0), turned to 90 degrees
- moved R42 168.6 mm to (127.3, 108.8), turned to 180 degrees
- moved C2 165.7 mm to (119.8, 114.6), turned to 90 degrees
- moved J10 165.6 mm to (107.8, 115.1), turned to 90 degrees
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
Commit message: Updated Contactor, fan, and strobe layout
Parts:
- removed ? (x2): , 
- removed C1, C2, C3: 1uF, Capacitor_SMD:C_0805_2012Metric
- added R10: R, Resistor_SMD:R_0805_2012Metric, F.Cu at (389.0, 121.0)
- added R12: R, Resistor_SMD:R_0805_2012Metric, F.Cu at (387.8, 103.0)
- added R8: R, Resistor_SMD:R_0805_2012Metric, F.Cu at (390.5, 140.1)
- C16, C17, C18, C19, C20, C21, C4, C8, C9, D1, D15, D16, D17, D18, D2, D3, D4, D5, D6, D7, D8, D9, R13, R14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: moved to B.Cu
- C22, C23, C24, R41, R42, R43: moved to F.Cu
- D11, D14, D21: value V2F22HM -> 1N4148WS; footprint UTSVT_Passive:V2F22HM -> Diode_SMD:D_SOD-323F
- moved C20 281.4 mm to (396.9, 108.4)
- moved C18 280.6 mm to (396.1, 126.0)
- moved C9 279.2 mm to (394.9, 91.4)
- moved D10 278.1 mm to (393.8, 140.1)
- moved D20 277.9 mm to (393.8, 103.0)
- moved C16 277.4 mm to (396.9, 146.0), turned to -90 degrees
- moved C17 277.4 mm to (394.9, 146.0), turned to -90 degrees
- moved R41 277.2 mm to (403.9, 146.0), turned to -90 degrees
- moved C21 277.2 mm to (394.7, 108.4)
- moved R43 277.1 mm to (403.8, 108.3), turned to -90 degrees
- moved C19 276.6 mm to (394.1, 126.0)
- moved R42 276.4 mm to (403.1, 126.0), turned to -90 degrees
- moved D13 276.0 mm to (391.9, 121.0)
- moved R9 276.0 mm to (399.2, 108.4), turned to 90 degrees
- moved R5 275.7 mm to (398.9, 146.0), turned to -90 degrees
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Connections:
- D10 pad 3: /HV+_Sense -> Net-(J9-Pin_4)
- D13 pad 3: /HV-_Sense -> Net-(J10-Pin_4)
- D20 pad 3: /Array_Sense -> Net-(J11-Pin_4)
- J10 pad 4: /HV-_Sense -> Net-(J10-Pin_4)
- J11 pad 4: /Array_Sense -> Net-(J11-Pin_4)
- J9 pad 4: /HV+_Sense -> Net-(J9-Pin_4)

Commit message: Started new skinny layout
Parts:
- removed SW1: SW_Rotary2x6, Connector_Molex:Molex_Micro-Fit_3.0_43045-1412_2x07_P3.00mm_Vertical
- added J3: Conn_01x04, UTSVT_Connectors:Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical, F.Cu at (137.0, 101.0)
- R41, R42, R43: value 50 -> 49.9
- moved R43 304.7 mm to (101.6, 146.7), turned to 0 degrees
- moved R2 303.6 mm to (96.7, 119.1), turned to 180 degrees
- moved D20 302.3 mm to (96.3, 156.8), turned to -90 degrees
- moved R9 300.6 mm to (101.6, 151.4), turned to 180 degrees
- moved U2 300.4 mm to (96.6, 116.1), turned to 90 degrees
- moved U7 300.3 mm to (101.6, 151.8), turned to -90 degrees
- moved C24 299.5 mm to (96.3, 160.2), turned to 0 degrees
- moved C9 299.3 mm to (96.6, 115.1), turned to 0 degrees
- moved C20 298.8 mm to (101.6, 153.6), turned to 180 degrees
- moved R12 297.6 mm to (96.3, 162.8), turned to 0 degrees
- moved C8 297.2 mm to (96.6, 113.1), turned to 0 degrees
- moved C21 296.9 mm to (101.6, 155.9), turned to 180 degrees
- moved R1 295.1 mm to (96.5, 111.1), turned to 180 degrees
- moved Q4 294.0 mm to (101.6, 159.4), turned to -90 degrees
- moved Q3 293.6 mm to (96.6, 109.8), turned to 90 degrees
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Connections:
- J1 pad 16: unconnected-(J1-Pad16) -> GND
Other:
- board outline added: 50 x 124 mm
- board text added: "USB"
