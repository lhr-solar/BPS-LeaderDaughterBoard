File: BPS-Leader.kicad_sch (KiCad schematic)
At the start: 18 parts, among them J10 Fan2, J11 Fan3, J12 Fan4, J13 HV+ Connector, J14 HV- Connector, J15 Array Connector, J17 Fan5, J18 Strobe_Conn, J19 ADC SPI, J20 Fan I2C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

Commit message: need to find a spot for the 3 new connectors and also flip the old connectors and also finish traces to leadersom
Parts:
- removed J23: lSOMconn, Connector_Molex:Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical, symbol Connector_Generic:Conn_01x04
- removed U1: PeripheralSOM, UTSVT_Special:PeripheralSOM, symbol utsvt-misc:PeripheralSOM
- added J1: ~, UTSVT_Special:LeaderSOM, symbol utsvt-connectors:LSOM_DaughterConn
- added J2: CarPowerConnector, Connector_Molex:Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical, symbol utsvt-connectors:CarPowerConnector
- added J3: CANconn, Connector_Molex:Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical, symbol Connector_Generic:Conn_01x02
- added J5: CANconn2, Connector_Molex:Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical, symbol Connector_Generic:Conn_01x02
- added J6: I-CanConn, Connector_Molex:Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical, symbol Connector_Generic:Conn_01x04
Connections:
- net +12V: now also J1.21 (12VExt), J1.22 (12VExt), J1.23 (12VExt), J1.24 (12VExt), J2.1 (+12V), J6.1 (Pin_1)
- net +3.3V: now also J1.1 (+3.3V), J1.2 (+3.3V), J1.3 (+3.3V), J1.4 (+3.3V), J1.45 (+3.3V), J1.46 (+3.3V), J1.47 (+3.3V), J1.48 (+3.3V)
- net ADDRSEL_FAN: now also J1.44 (ADC1_IN3)
- net Array SENSE: now also J1.31 (ADC1_IN10)
- net CAN_H: now also J1.30 (CCAN_H), J3.1 (Pin_1), J5.1 (Pin_1)
- net CAN_L: now also J1.32 (CCAN_L), J3.2 (Pin_2), J5.2 (Pin_2)
- net CS: now also J1.16 (SPI2_CS)
- net FanError: now also J1.42 (ADC1_IN2)
- net GND: now also J1.10 (GND), J1.12 (GND), J1.13 (GND), J1.15 (GND), J1.25 (GND), J1.26 (GND), J1.27 (GND), J1.28 (GND), J1.29 (GND), J1.38 (GND), J1.40 (GND), J2.2 (GND)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
- net HV+ SENSE: now also J1.41 (ADC1_IN11)
- net HV- SENSE: now also J1.43 (ADC1_IN12)
- net SCL: now also J1.7 (I2C1_SCL)
- net SCLK: now also J1.20 (SPI2_SCK)
- net SDA: now also J1.5 (I2C1_SDA)
- net SDI: now also J1.18 (SPI2_MOSI)
- net SDO: now also J1.14 (SPI2_MISO)
- net Seg1Sense: now also J1.11 (I2C3_SCL)
- net Seg2Sense: now also J1.17 (UART5_TX)
- net SegEN: now also J1.9 (I2C3_SDA)
- net Strobe_EN: now also J1.19 (UART5_RX)
- new net I-CAN_H: J1.6 (ICAN_H), J6.3 (Pin_3)
- new net I-CAN_L: J1.8 (ICAN_L), J6.2 (Pin_2)
- no-connect marks 4 -> 6

Commit message: Traces completed, no drc electrical errors. need to clean up silkscreen.
Connections:
- net +12V: now also J10.3 (Pin_3), J11.3 (Pin_3), J12.3 (Pin_3), J13.4 (Pin_4), J14.4 (Pin_4), J15.4 (Pin_4), J17.3 (Pin_3), J9.3 (Pin_3); no longer J10.1 (Pin_1), J11.1 (Pin_1), J12.1 (Pin_1), J13.1 (Pin_1), J14.1 (Pin_1), J15.1 (Pin_1), J17.1 (Pin_1), J9.1 (Pin_1)
- net Array Contactor/Low: now also J15.3 (Pin_3); no longer J15.2 (Pin_2)
- net Array SENSE: now also J15.2 (Pin_2); no longer J15.3 (Pin_3)
- net Battery segments/Low1: now also J21.3 (Pin_3); no longer J21.2 (Pin_2)
- net Battery segments/Low2: now also J22.3 (Pin_3); no longer J22.2 (Pin_2)
- net CAN_H: now also J3.2 (Pin_2), J5.2 (Pin_2); no longer J3.1 (Pin_1), J5.1 (Pin_1)
- net CAN_L: now also J3.1 (Pin_1), J5.1 (Pin_1); no longer J3.2 (Pin_2), J5.2 (Pin_2)
- net F1TACH: now also J9.1 (Pin_1); no longer J9.3 (Pin_3)
- net F2TACH: now also J10.1 (Pin_1); no longer J10.3 (Pin_3)
- net F3TACH: now also J11.1 (Pin_1); no longer J11.3 (Pin_3)
- net F4TACH: now also J12.1 (Pin_1); no longer J12.3 (Pin_3)
- net F5TACH: now also J17.1 (Pin_1); no longer J17.3 (Pin_3)
- net GND: now also J13.1 (Pin_1), J14.1 (Pin_1), J15.1 (Pin_1); no longer J13.4 (Pin_4), J14.4 (Pin_4), J15.4 (Pin_4)
- net HV+ SENSE: now also J13.2 (Pin_2); no longer J13.3 (Pin_3)
- net HV+ contactor/Low: now also J13.3 (Pin_3); no longer J13.2 (Pin_2)
- net HV- Contactor/EN: now also JP1.2 (B); no longer JP1.1 (A)
- net HV- Contactor/Low: now also J14.3 (Pin_3); no longer J14.2 (Pin_2)
- net HV- SENSE: now also J14.2 (Pin_2); no longer J14.3 (Pin_3)
- net HV-_EN: now also JP1.1 (A); no longer JP1.2 (B)
- net Seg1Sense: now also J21.2 (Pin_2); no longer J21.3 (Pin_3)
- net Seg2Sense: now also J22.2 (Pin_2); no longer J22.3 (Pin_3)
Other:
- moved on the sheet: J8, JP1

Commit message: enable signals added for contactors.....
Connections:
- net Array_EN: now also J1.42 (ADC1_IN2)
- net FanError: no longer J1.42 (ADC1_IN2)
- net HV+_EN: now also J1.11 (I2C3_SCL)
- net HV-_EN: now also J1.17 (UART5_TX)
- net Seg1Sense: no longer J1.11 (I2C3_SCL)
- net Seg2Sense: no longer J1.17 (UART5_TX)
Changed lines of the file:
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@@
-	)
-	(junction
-		(at 50.8 87.63)
-		(diameter 0)
-		(color 0 0 0 0)
 	)
 	(junction
@@
 	(wire
 		(pts
-			(xy 50.8 88.9) (xy 50.8 87.63)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 262.89 36.83) (xy 262.89 38.1)
 		)
@@
 		)
 	)
-	(label "Seg2Sense"
+	(label "HV-_EN"
 		(at 229.87 66.04 180)
 		(fields_autoplaced yes)
@@
 	)
 	(label "HV-_EN"
-		(at 50.8 88.9 0)
+		(at 50.8 85.09 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 	)
-	(label "FanError"
+	(label "Array_EN"
 		(at 262.89 33.02 0)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(label "Seg1Sense"
+	(label "HV+_EN"
 		(at 229.87 73.66 180)
 		(fields_autoplaced yes)
