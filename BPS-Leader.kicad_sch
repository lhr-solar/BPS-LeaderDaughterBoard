File: BPS-Leader.kicad_sch (KiCad schematic)
At the start: 23 parts, among them J1 E-STOP, J10 Strobe_Conn, J11 ADC SPI, J12 Fan I2C, J13 lSOMconn, J14 Fan5_test, J15 Fan1_test, J16 Fan2_test, J17 Fan3_test, J18 Fan4_test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

Commit message: preliminary schematic completed
Parts:
- added J21: Segment1 Connector, Connector_Molex:Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical, symbol Connector_Generic:Conn_01x04
- added J22: Segment2 Connector, Connector_Molex:Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical, symbol Connector_Generic:Conn_01x04
- renumbered J20 to J1, J3 to J10, J4 to J11, J5 to J12, J6 to J13, J8 to J14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
Connections:
- net +12V: now also J21.1 (Pin_1), J22.1 (Pin_1)
- net GND: now also J21.4 (Pin_4), J22.4 (Pin_4)
- new net Battery segments/Low1: J21.2 (Pin_2)
- new net Battery segments/Low2: J22.2 (Pin_2)
- new net Seg1Sense: J21.3 (Pin_3)
- new net Seg2Sense: J22.3 (Pin_3)
Other:
- added sheet Battery segments (drivernosense.kicad_sch)
- note added: "Fan Contactors"
- note added: "Segment Contactors"
- note removed: "FANS!"
- moved on the sheet: J1

Commit message: Very rough layout of the board - maybe too long?
Parts:
- removed J1: HV-_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J16: Fan5_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J2: HV+_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J3: Array_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J4: Fan1_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J5: Fan2_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J6: Fan3_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- removed J7: Fan4_test, Connector_PinHeader_2.54mm:PinHeader_1x01_P2.54mm_Vertical, symbol Connector:Conn_01x01_Pin
- added J4: Fan I2C, Connector_PinHeader_2.54mm:PinHeader_2x04_P2.54mm_Vertical, symbol Connector_Generic:Conn_02x04_Odd_Even
Connections:
- net Array_Current: now also J4.8 (Pin_8)
- net FAN1_Current: now also J4.1 (Pin_1)
- net FAN2_Current: now also J4.3 (Pin_3)
- net FAN3_Current: now also J4.5 (Pin_5)
- net FAN4_Current: now also J4.7 (Pin_7)
- net FAN5_Current: now also J4.2 (Pin_2)
- net HV+_Current: now also J4.4 (Pin_4)
- net HV-_EN: now also J4.6 (Pin_6)
Other:
- note added: "Test Pins"
- note removed: "Logic Analyzer"

Commit message: most traces completed - need leaderSOM to finish. need to correct silkscreen issues.
Connections:
- net +12V: now also J23.1 (Pin_1); no longer J23.4 (Pin_4)
- net Array_Current: now also J4.4 (Pin_4); no longer J4.8 (Pin_8)
- net CAN_H: now also J23.3 (Pin_3); no longer J23.2 (Pin_2)
- net CAN_L: now also J23.2 (Pin_2); no longer J23.3 (Pin_3)
- net FAN1_Current: now also J4.7 (Pin_7); no longer J4.1 (Pin_1)
- net FAN2_Current: now also J4.5 (Pin_5); no longer J4.3 (Pin_3)
- net FAN3_Current: now also J4.3 (Pin_3); no longer J4.5 (Pin_5)
- net FAN4_Current: now also J4.1 (Pin_1); no longer J4.7 (Pin_7)
- net GND: now also J23.4 (Pin_4); no longer J23.1 (Pin_1)
- net HV+_Current: now also J4.8 (Pin_8); no longer J4.4 (Pin_4)
- net HV-_Current: now also J4.6 (Pin_6)
- net HV-_EN: no longer J4.6 (Pin_6)
Other:
- moved on the sheet: J23
Changed lines of the file:
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@@
 	)
 	(junction
-		(at 222.25 50.8)
+		(at 207.01 50.8)
 		(diameter 0)
 		(color 0 0 0 0)
@@
 	(wire
 		(pts
+			(xy 207.01 55.88) (xy 212.09 55.88)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 142.24 135.89) (xy 142.24 129.54)
 		)
@@
 	(wire
 		(pts
+			(xy 207.01 50.8) (xy 212.09 50.8)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 139.7 143.51) (xy 152.4 143.51)
 		)
@@
 	(wire
 		(pts
+			(xy 207.01 53.34) (xy 212.09 53.34)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 45.72 86.36) (xy 45.72 83.82)
 		)
@@
 		)
 	)
+	(wire
+		(pts
+			(xy 207.01 58.42) (xy 212.09 58.42)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
 	(rectangle
 		(start 72.39 12.7)
@@
 		)
 	)
-	(label "Array_Current"
+	(label "HV+_Current"
 		(at 153.67 64.77 0)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(label "FAN1_Current"
+	(label "FAN4_Current"
 		(at 140.97 57.15 180)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(label "FAN4_Current"
+	(label "FAN1_Current"
 		(at 140.97 64.77 180)
 		(fields_autoplaced yes)
@@
 	)
 	(label "CAN_L"
-		(at 222.25 53.34 0)
+		(at 207.01 53.34 0)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 	)
-	(label "FAN2_Current"
+	(label "FAN3_Current"
 		(at 140.97 59.69 180)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(label "HV+_Current"
+	(label "Array_Current"
 		(at 153.67 59.69 0)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(label "FAN3_Current"
+	(label "FAN2_Current"
 		(at 140.97 62.23 180)
 		(fields_autoplaced yes)
@@
 		)
 	)
-	(label "HV-_EN"
+	(label "HV-_Current"
 		(at 153.67 62.23 0)
 		(fields_autoplaced yes)
@@
 	)
 	(label "CAN_H"
-		(at 222.25 55.88 0)
+		(at 207.01 55.88 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(symbol
 		(lib_id "Connector_Generic:Conn_01x04")
-		(at 217.17 55.88 180)
+		(at 217.17 53.34 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "J23"
-			(at 210.566 53.086 0)
+			(at 223.774 56.134 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "lSOMconn"
-			(at 210.566 55.626 0)
+			(at 223.774 53.594 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" "Connector_Molex:Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical"
-			(at 217.17 55.88 0)
+			(at 217.17 53.34 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "~"
-			(at 217.17 55.88 0)
+			(at 217.17 53.34 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Generic connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)"
-			(at 217.17 55.88 0)
+			(at 217.17 53.34 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "power:+12V")
-		(at 222.25 50.8 0)
+		(at 207.01 50.8 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR018"
-			(at 222.25 54.61 0)
+			(at 207.01 54.61 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "+12V"
-			(at 222.25 45.72 0)
+			(at 207.01 45.72 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 222.25 50.8 0)
+			(at 207.01 50.8 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 222.25 50.8 0)
+			(at 207.01 50.8 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"+12V\""
-			(at 222.25 50.8 0)
+			(at 207.01 50.8 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 222.25 58.42 0)
+		(at 207.01 58.42 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR019"
-			(at 222.25 64.77 0)
+			(at 207.01 64.77 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND"
-			(at 222.25 62.484 0)
+			(at 207.01 62.484 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 222.25 58.42 0)
+			(at 207.01 58.42 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 222.25 58.42 0)
+			(at 207.01 58.42 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 222.25 58.42 0)
+			(at 207.01 58.42 0)
 			(effects
 				(font
@@
 	(symbol
 		(lib_id "power:PWR_FLAG")
-		(at 222.25 50.8 0)
+		(at 207.01 50.8 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#FLG01"
-			(at 222.25 48.895 0)
+			(at 207.01 48.895 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "PWR_FLAG"
-			(at 222.2499 46.99 90)
+			(at 207.0099 46.99 90)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 222.25 50.8 0)
+			(at 207.01 50.8 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" "~"
-			(at 222.25 50.8 0)
+			(at 207.01 50.8 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Special symbol for telling ERC where power comes from"
-			(at 222.25 50.8 0)
+			(at 207.01 50.8 0)
 			(effects
 				(font
