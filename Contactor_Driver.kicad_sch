File: Contactor_Driver.kicad_sch (KiCad schematic)
At the start: 20 parts, among them J9 Conn_01x04, Q7 NTR4003NT1G, Q8 VND5N07-E, Q9 BUK9M23-80E, U2 SI8261ABC-IS

Commit message: Finished comments for Strobe Light and started resolving them for Contactor
Parts:
- removed C4: 100nF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed C5: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed D11: ContactorEn, LED_SMD:LED_0805_2012Metric, symbol Device:D
- removed Q7: NTR4003NT1G, Package_TO_SOT_SMD:SOT-23, symbol Device:Q_NMOS_GSD
- removed Q8: VND5N07-E, Package_TO_SOT_SMD:TO-252-2, symbol Device:Q_NMOS_GDS
- removed R23: 0, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed R24: 10k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed R25: 1.5k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed R26: 470, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed U2: SI8261ABC-IS, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol utsvt-bps:SI8261ABC-IS
- added C16: 100nF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- added C17: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- added C22: C, symbol Device:C
- added Q8: BUK9M23-80E, Package_TO_SOT_SMD:LFPAK33, symbol Transistor_FET:BUK9M23-80EX
- added R41: R, symbol Device:R
- added U5: SI8261ABC-IS, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol utsvt-bps:SI8261ABC-IS
Connections:
- net +12V: now also C16.1, C17.1, U5.8 (VDD)
- net CONTACTOR_V-: now also Q8.5 (D)
- net Contactor_EN: now also R41.1
- net Contactor_Sense: now also C22.1
- net GND: now also C22.2, U5.3 (CATHODE)
- net GNDPWR: now also C16.2, C17.2, U5.5 (GND)
- net PWM_ISO: now also U5.6 (VO), U5.7 (VO)
- net at C6.2, D12.2 (A), D14.2 (A)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: now also Q8.1 (S), Q8.2 (S), Q8.3 (S)
- net at C6.1, D12.1 (K), R27.2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: now also Q8.4 (G)
- new net: R41.2, U5.2 (ANODE)
Other:
- note removed: "CHANGE PART (FILLER)"
- note removed: "Keep bypass caps clsoe to VDD pin"
- moved on the sheet: D10A, D10B, J9

Commit message: Started Ignition and nearly done with Contactor Circuit
Other:
- note added: "Change pullup to 100k?"
Changed lines of the file:
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@@
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "Change pullup to 100k?" (at 163.83 48.895 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )

Commit message: Added new SOM connector layout
Parts:
- removed R27: 10k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added C1: 1uF, symbol Device:C
- added D11: V2F22HM, UTSVT_Passive:V2F22HM, symbol Diode:C3D25170H
- added D25: Green, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, symbol Device:LED_Small
- added Q1: NMOS, Package_TO_SOT_SMD:LFPAK33, symbol Transistor_FET:BUK9M23-80EX
- added R2, R5: 100k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added R26: 10k, symbol Device:R
Connections:
- net +12V: now also C1.1, D11.1 (K), R2.1, R26.1
- net CONTACTOR_V-: now also D11.2 (A), D25.1 (K), Q1.5 (D)
- net GNDPWR: now also C1.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), R5.2
- net PWM_ISO: now also Q1.4 (G), R5.1
- net at C6.1, D12.1 (K), Q8.4 (G)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: now also R2.2
- new net: D25.2 (A), R26.2
Other:
- note removed: "Change pullup to 100k?"
- moved on the sheet: C22, D10A, D10B, J9

Commit message: New Contactor mosfet
Parts:
- removed C6: 100nF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed C7: 1u, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed D12: V2F22HM, UTSVT_Passive:V2F22HM, symbol Diode:C3D25170H
- removed D13: SMAJ43CA, Diode_SMD:D_SOD-923, symbol Diode:SZESD9B5.0ST5G
- removed D14: V2F22HM3/H, UTSVT_Passive:V2F22HM, symbol Device:D
- removed Q8, Q9: BUK9M23-80E, Package_TO_SOT_SMD:LFPAK33, symbol Transistor_FET:BUK9M23-80EX
- removed R2, R28: 100k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added D28: SMAJ43CA, Diode_SMD:D_SOD-923, symbol Diode:SZESD9B5.0ST5G
- C1: footprint (none) -> Capacitor_SMD:C_0805_2012Metric
- C22: value C -> 1uF; footprint (none) -> Capacitor_SMD:C_0805_2012Metric
- D25: P/N APTD2012LCGCK -> LHR971-KN1
- Q1: value NMOS -> BUK9M3R3-40HX; P/n (none) -> BUK9M3R3-40HX
- R26: footprint (none) -> Resistor_SMD:R_0805_2012Metric
Connections:
- net +12V: now also D28.2 (A2)
- net CONTACTOR_V-: now also D28.1 (A1)
Other:
- moved on the sheet: C1, C22, D10A, D10B, D11, D25, J9, R26, R5
