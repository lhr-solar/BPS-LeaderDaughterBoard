# Repository lhr-solar/BPS-LeaderDaughterBoard

File README.md:

# BPS-LeaderDaughterBoard

The BPS Leader-Daughter is a daugherboard for the LeaderSOM. Together they will read data from and control the BPS peripherals

## Switches LEDs
| # | Purpose |
| - | - |
| D1  | Strobe Light Indicator |
| D3  | HV+ Contactor Indicator |
| D6  | HV- Contactor Indicator |
| D9  | Array Contactor Indicator |

[**BOM**](BOM/BPS-LeaderDaughterBOM.xls)  
[**IBOM**](BOM/ibom.html)  
[**Partial Mouser Cart**](https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=2f994263ce7)  
[**All Components Mouser Cart**](https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=f3b4372aef)  

## PCB

## Schematic
[**PDF with all sheets**](BPS-LeaderDaughterSchematic.pdf)

## Links
[Gigavac Contactor Circuit PWM Application Note](https://sensata.com/sites/default/files/a/Sensata-gigavac-driving-contactors-with-external-pwm-app-note.pdf)  
[Texas Instruments note on driving Contactors](https://www.ti.com/lit/wp/slvaf35/slvaf35.pdf?ts=1699022514322&ref_url=https%253A%252F%252Fwww.google.com%252F)

## KiCad design BPS-Leader.kicad_pcb

Parts:
J1: LeaderSOM
J2: CarPowerConnector; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J3: CANconn; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J4, J20: Fan I2C; PinHeader_2x04_P2.54mm_Vertical
J5: CANconn2; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J6: I-CanConn; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J8: E-STOP; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J9: Fan1; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
J10: Fan2; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
J11: Fan3; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
J12: Fan4; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
J13: HV+ Connector; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J14: HV- Connector; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J15: Array Connector; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J17: Fan5; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
J18: Strobe_Conn; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J19: ADC SPI; PinHeader_2x04_P2.54mm_Vertical
J21: Segment1 Connector; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J22: Segment2 Connector; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
JP1: E-Stop Bypass; PinHeader_1x02_P2.54mm_Vertical

Connections:
+3.3V: J1.1 (+3.3V), J1.2 (+3.3V), J1.3 (+3.3V), J1.4 (+3.3V), J1.45 (+3.3V), J1.46 (+3.3V), J1.47 (+3.3V), J1.48 (+3.3V); also elsewhere on the board
+12V: J1.21 (12VExt), J1.22 (12VExt), J1.23 (12VExt), J1.24 (12VExt), J2.1 (+12V), J6.1, J9.3, J10.3, J11.3, J12.3, J13.4, J14.4, J15.4, J17.3, J18.1, J21.1, J22.1; also elsewhere on the board
/ADDRSEL_FAN: J1.44 (ADC1_IN3), J20.5, J20.6; also elsewhere on the board
/Array Contactor/Low: J15.3; also elsewhere on the board
/Array SENSE: J1.31 (ADC1_IN10), J15.2
/Array_Current: J4.4; also elsewhere on the board
/Array_EN: J1.42 (ADC1_IN2); also elsewhere on the board
/Battery segments/Low1: J21.3; also elsewhere on the board
/Battery segments/Low2: J22.3; also elsewhere on the board
/CAN_H: J1.30 (CCAN_H), J3.2, J5.2
/CAN_L: J1.32 (CCAN_L), J3.1, J5.1
/CS: J1.16 (SPI2_CS), J19.1, J19.2; also elsewhere on the board
/F1TACH: J9.1; also elsewhere on the board
/F2TACH: J10.1; also elsewhere on the board
/F3TACH: J11.1; also elsewhere on the board
/F4TACH: J12.1; also elsewhere on the board
/F5TACH: J17.1; also elsewhere on the board
/FAN1_Current: J4.7; also elsewhere on the board
/FAN2_Current: J4.5; also elsewhere on the board
/FAN3_Current: J4.3; also elsewhere on the board
/FAN4_Current: J4.1; also elsewhere on the board
/FAN5_Current: J4.2; also elsewhere on the board
/Fan1/Low: J9.2; also elsewhere on the board
/Fan2/Low: J10.2; also elsewhere on the board
/Fan3/Low: J11.2; also elsewhere on the board
/Fan4/Low: J12.2; also elsewhere on the board
/Fan5/Low: J17.2; also elsewhere on the board
/FanError: J20.7, J20.8; also elsewhere on the board
/HV+ SENSE: J1.41 (ADC1_IN11), J13.2
/HV+ contactor/Low: J13.3; also elsewhere on the board
/HV+_Current: J4.8; also elsewhere on the board
/HV+_EN: J1.11 (I2C3_SCL); also elsewhere on the board
/HV- Contactor/EN: J8.2, JP1.2 (B); also elsewhere on the board
/HV- Contactor/Low: J14.3; also elsewhere on the board
/HV- SENSE: J1.43 (ADC1_IN12), J14.2
/HV-_Current: J4.6; also elsewhere on the board
/HV-_EN: J1.17 (UART5_TX), J8.1, JP1.1 (A)
/I-CAN_H: J1.6 (ICAN_H), J6.3
/I-CAN_L: J1.8 (ICAN_L), J6.2
/SCL: J1.7 (I2C1_SCL), J20.3, J20.4; also elsewhere on the board
/SCLK: J1.20 (SPI2_SCK), J19.5, J19.6; also elsewhere on the board
/SDA: J1.5 (I2C1_SDA), J20.1, J20.2; also elsewhere on the board
/SDI: J1.18 (SPI2_MOSI), J19.3, J19.4; also elsewhere on the board
/SDO: J1.14 (SPI2_MISO), J19.7, J19.8; also elsewhere on the board
/Seg1Sense: J21.2
/Seg2Sense: J22.2
/SegEN: J1.9 (I2C3_SDA); also elsewhere on the board
/Strobe Light/Low: J18.2; also elsewhere on the board
/Strobe_EN: J1.19 (UART5_RX); also elsewhere on the board
GND: J1.10 (GND), J1.12 (GND), J1.13 (GND), J1.15 (GND), J1.25 (GND), J1.26 (GND), J1.27 (GND), J1.28 (GND), J1.29 (GND), J1.38 (GND), J1.40 (GND), J2.2 (GND), J6.4, J13.1, J14.1, J15.1, J21.4, J22.4; also elsewhere on the board

Notes on the sheet:
FAN CONTROL
-Contactors
ADC
Segment Contactors
Test Pins
Fan Contactors
Strobe Light

Parts:
C16, C18: 0.1uF; C_0805_2012Metric
C17: 0.15uF; C_0805_2012Metric
D17: Green; D_0805_2012Metric(adjsilk)
D18, D19, D20: 1N448W; D_0805_2012Metric(adjsilk)
Q7: IRLML0030; SOT-23
R33: 100k; R_0805_2012Metric
R34: 10k; R_0805_2012Metric
R35: 1k; R_0805_2012Metric
R36: 2.8m; R_2512_6332Metric
R37, R38: 10; R_0805_2012Metric
R39: 1; R_0805_2012Metric
U7: INA180A2; SOT-23-5(movedsilk)

Connections:
+3.3V: C16.1, C18.1, D19.1 (K), U7.5 (V+); also elsewhere on the board
+12V: D18.1 (K), R34.1, R36.1, R37.1; also elsewhere on the board
/FAN1_Current: D19.2 (A), D20.1 (K), R39.2, U7.1; also elsewhere on the board
/Fan1/Low: D17.1 (K), D18.2 (A), Q7.3 (D); also elsewhere on the board
/Fan1_EN: R33.1, R35.1; also elsewhere on the board
GND: C16.2, C18.2, D20.2 (A), Q7.2 (S), R33.2, U7.2 (GND); also elsewhere on the board
unnamed: D17.2 (A), R34.2
unnamed: Q7.1 (G), R35.2
unnamed: R36.2, R38.1
unnamed: C17.1, R37.2, U7.3 (+)
unnamed: C17.2, R38.2, R39.1, U7.4 (-)

Parts of its further copies:
C4, C6, C7, C9, C10, C12, C13, C15, C19, C21, C22, C24, C27, C29: 0.1uF; C_0805_2012Metric
C5, C8, C11, C14, C20, C23, C28: 0.15uF; C_0805_2012Metric
D1, D5, D9, D13, D21, D27, D31: Green; D_0805_2012Metric(adjsilk)
D2, D3, D4, D6, D7, D8, D10, D11, D12, D14, D15, D16, D22, D23, D24, D28, D29, D30, D32, D33, D34: 1N448W; D_0805_2012Metric(adjsilk)
Q1, Q4, Q5, Q6, Q8, Q10, Q11: IRLML0030; SOT-23
R1, R12, R19, R26, R40, R50, R65: 100k; R_0805_2012Metric
R2, R13, R20, R27, R41, R51, R66: 10k; R_0805_2012Metric
R3, R14, R21, R28, R42, R52, R67: 1k; R_0805_2012Metric
R4, R15, R22, R29, R43, R53, R68: 2.8m; R_2512_6332Metric
R5, R6, R16, R17, R23, R24, R30, R31, R44, R45, R54, R55, R69, R70: 10; R_0805_2012Metric
R7, R18, R25, R32, R46, R56, R71: 1; R_0805_2012Metric
U3, U4, U5, U6, U8, U9, U11: INA180A2; SOT-23-5(movedsilk)

Connections of its further copies:
+3.3V: C4.1, C6.1, C7.1, C9.1, C10.1, C12.1, C13.1, C15.1, C19.1, C21.1, C22.1, C24.1, C27.1, C29.1, D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), D23.1 (K), D29.1 (K), D33.1 (K), U3.5 (V+), U4.5 (V+), U5.5 (V+), U6.5 (V+), U8.5 (V+), U9.5 (V+), U11.5 (V+); also elsewhere on the board
+12V: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), D22.1 (K), D28.1 (K), D32.1 (K), R2.1, R4.1, R5.1, R13.1, R15.1, R16.1, R20.1, R22.1, R23.1, R27.1, R29.1, R30.1, R41.1, R43.1, R44.1, R51.1, R53.1, R54.1, R66.1, R68.1, R69.1; also elsewhere on the board
/Array Contactor/Low: D13.1 (K), D14.2 (A), Q6.3 (D); also elsewhere on the board
/Array_Current: D15.2 (A), D16.1 (K), R32.2, U6.1; also elsewhere on the board
/Array_EN: R26.1, R28.1; also elsewhere on the board
/FAN2_Current: D23.2 (A), D24.1 (K), R46.2, U8.1; also elsewhere on the board
/FAN3_Current: D29.2 (A), D30.1 (K), R56.2, U9.1; also elsewhere on the board
/FAN4_Current: D33.2 (A), D34.1 (K), R71.2, U11.1; also elsewhere on the board
/FAN5_Current: D3.2 (A), D4.1 (K), R7.2, U3.1; also elsewhere on the board
/Fan2/Low: D21.1 (K), D22.2 (A), Q8.3 (D); also elsewhere on the board
/Fan2_EN: R40.1, R42.1; also elsewhere on the board
/Fan3/Low: D27.1 (K), D28.2 (A), Q10.3 (D); also elsewhere on the board
/Fan3_EN: R50.1, R52.1; also elsewhere on the board
/Fan4/Low: D31.1 (K), D32.2 (A), Q11.3 (D); also elsewhere on the board
/Fan4_EN: R65.1, R67.1; also elsewhere on the board
/Fan5/Low: D1.1 (K), D2.2 (A), Q1.3 (D); also elsewhere on the board
/Fan5_EN: R1.1, R3.1; also elsewhere on the board
/HV+ contactor/Low: D5.1 (K), D6.2 (A), Q4.3 (D); also elsewhere on the board
/HV+_Current: D7.2 (A), D8.1 (K), R18.2, U4.1; also elsewhere on the board
/HV+_EN: R12.1, R14.1; also elsewhere on the board
/HV- Contactor/EN: R19.1, R21.1; also elsewhere on the board
/HV- Contactor/Low: D9.1 (K), D10.2 (A), Q5.3 (D); also elsewhere on the board
/HV-_Current: D11.2 (A), D12.1 (K), R25.2, U5.1; also elsewhere on the board
GND: C4.2, C6.2, C7.2, C9.2, C10.2, C12.2, C13.2, C15.2, C19.2, C21.2, C22.2, C24.2, C27.2, C29.2, D4.2 (A), D8.2 (A), D12.2 (A), D16.2 (A), D24.2 (A), D30.2 (A), D34.2 (A), Q1.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q8.2 (S), Q10.2 (S), Q11.2 (S), R1.2, R12.2, R19.2, R26.2, R40.2, R50.2, R65.2, U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U8.2 (GND), U9.2 (GND), U11.2 (GND); also elsewhere on the board
unnamed: D1.2 (A), R2.2
unnamed: D5.2 (A), R13.2
unnamed: D9.2 (A), R20.2
unnamed: D13.2 (A), R27.2
unnamed: D21.2 (A), R41.2
unnamed: D27.2 (A), R51.2
unnamed: D31.2 (A), R66.2
unnamed: Q1.1 (G), R3.2
unnamed: Q4.1 (G), R14.2
unnamed: Q5.1 (G), R21.2
unnamed: Q6.1 (G), R28.2
unnamed: Q8.1 (G), R42.2
unnamed: Q10.1 (G), R52.2
unnamed: Q11.1 (G), R67.2
unnamed: R4.2, R6.1
unnamed: R15.2, R17.1
unnamed: R22.2, R24.1
unnamed: R29.2, R31.1
unnamed: R43.2, R45.1
unnamed: R53.2, R55.1
unnamed: R68.2, R70.1
unnamed: C5.1, R5.2, U3.3 (+)
unnamed: C5.2, R6.2, R7.1, U3.4 (-)
unnamed: C8.1, R16.2, U4.3 (+)
unnamed: C8.2, R17.2, R18.1, U4.4 (-)
unnamed: C11.1, R23.2, U5.3 (+)
unnamed: C11.2, R24.2, R25.1, U5.4 (-)
unnamed: C14.1, R30.2, U6.3 (+)
unnamed: C14.2, R31.2, R32.1, U6.4 (-)
unnamed: C20.1, R44.2, U8.3 (+)
unnamed: C20.2, R45.2, R46.1, U8.4 (-)
unnamed: C23.1, R54.2, U9.3 (+)
unnamed: C23.2, R55.2, R56.1, U9.4 (-)
unnamed: C28.1, R69.2, U11.3 (+)
unnamed: C28.2, R70.2, R71.1, U11.4 (-)

Notes on the sheet:
Driver with current sense

Parts:
D25: Green; D_0805_2012Metric(adjsilk)
Q9: IRLML0030; SOT-23
R47: 100k; R_0805_2012Metric
R48: 10k; R_0805_2012Metric
R49: 1k; R_0805_2012Metric

Connections:
+12V: R48.1; also elsewhere on the board
/Strobe Light/Low: D25.1 (K), Q9.3 (D); also elsewhere on the board
/Strobe_EN: R47.1, R49.1; also elsewhere on the board
GND: Q9.2 (S), R47.2; also elsewhere on the board
unnamed: D25.2 (A), R48.2
unnamed: Q9.1 (G), R49.2

Notes on the sheet:
Strobe Light Driver

Parts:
C25, C26: 1uF; C_0805_2012Metric
R57, R58, R59, R60, R61, R63: 100k; R_0805_2012Metric
R62: 33k; R_0805_2012Metric
R64: 15k; R_0805_2012Metric
U10: EMC2305-1-AP-TR; QFN16_4x4MC_MCH

Connections:
+3.3V: C25.1, C26.1, R57.1, R58.1, R59.1, R60.1, R61.1, R62.1, R63.1, R64.1, U10.3 (VDD); also elsewhere on the board
/ADDRSEL_FAN: R62.2, U10.4 (ADDR_SEL); also elsewhere on the board
/F1TACH: R57.2, U10.6 (TACH1); also elsewhere on the board
/F2TACH: R58.2, U10.8 (TACH2); also elsewhere on the board
/F3TACH: R59.2, U10.10 (TACH3); also elsewhere on the board
/F4TACH: R60.2, U10.14 (TACH4); also elsewhere on the board
/F5TACH: R61.2, U10.16 (TACH5); also elsewhere on the board
/Fan1_EN: U10.5 (PWM1); also elsewhere on the board
/Fan2_EN: U10.7 (PWM2); also elsewhere on the board
/Fan3_EN: U10.9 (PWM3); also elsewhere on the board
/Fan4_EN: U10.13 (PWM4); also elsewhere on the board
/Fan5_EN: U10.15 (PWM5); also elsewhere on the board
/FanError: R63.2, U10.12 (*ALERT); also elsewhere on the board
/SCL: U10.2 (SMCLK); also elsewhere on the board
/SDA: U10.1 (SMDATA); also elsewhere on the board
GND: C25.2, C26.2, U10.HTAB (EPAD); also elsewhere on the board
unnamed: R64.2, U10.11 (CLK)

Notes on the sheet:
Default Fan Speed
Pull-up resistors :)
I2C1_SCL I2C1_SDA

Parts:
Q2, Q3: IRLML0030; SOT-23
R8, R10: 100k; R_0805_2012Metric
R9, R11: 1k; R_0805_2012Metric

Connections:
/Battery segments/Low1: Q2.3 (D); also elsewhere on the board
/Battery segments/Low2: Q3.3 (D); also elsewhere on the board
/SegEN: R8.1, R9.1, R10.1, R11.1; also elsewhere on the board
GND: Q2.2 (S), Q3.2 (S), R8.2, R10.2; also elsewhere on the board
unnamed: Q2.1 (G), R9.2
unnamed: Q3.1 (G), R11.2

Notes on the sheet:
Battery Segment Drivers

Parts:
C1, C2, C3: 1uF; C_0805_2012Metric
U2: TLA2518IRTER; WQFN16_RTE_TEX

Connections:
+3.3V: C1.1, C3.1, U2.7 (AVDD), U2.10 (DVDD); also elsewhere on the board
/Array_Current: U2.1 (AIN2/GPIO2); also elsewhere on the board
/CS: U2.11 (*CS); also elsewhere on the board
/FAN1_Current: U2.2 (AIN3/GPIO3); also elsewhere on the board
/FAN2_Current: U2.3 (AIN4/GPIO4); also elsewhere on the board
/FAN3_Current: U2.4 (AIN5/GPIO5); also elsewhere on the board
/FAN4_Current: U2.5 (AIN6/GPIO6); also elsewhere on the board
/FAN5_Current: U2.6 (AIN7/GPIO7); also elsewhere on the board
/HV+_Current: U2.15 (AIN0/GPIO0); also elsewhere on the board
/HV-_Current: U2.16 (AIN1/GPIO1); also elsewhere on the board
/SCLK: U2.13 (SCLK); also elsewhere on the board
/SDI: U2.14 (SDI); also elsewhere on the board
/SDO: U2.12 (SDO); also elsewhere on the board
GND: C1.2, C2.1, C3.2, U2.9 (GND), U2.17 (GND); also elsewhere on the board
unnamed: C2.2, U2.8 (DECAP)

Board: 2 copper layers, 62.4 x 124.2 mm, 178 parts (8 on the bottom side), 99 nets.

Other parts of the board:
H1, H1#2, H1#3: MountingHole; MountingHole_3mm

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C25, C26, C3",0805,5,1uF,
"C10, C12, C13, C15, C16, C18, C19, C21, C22, C24, C27, C29, C4, C6, C7, C9",0805,16,0.1uF,
"C11, C14, C17, C20, C23, C28, C5, C8",0805,8,0.15uF,
"D1, D13, D17, D21, D25, D27, D31, D5, D9",0805,9,Green,
"D10, D11, D12, D14, D15, D16, D18, D19, D2, D20, D22, D23, D24, D28, D29, D3, D30, D32, D33, D34, D4, D6, D7, D8",0805,24,1N448W,
J1,LeaderSOM,1,~,
J10,Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical,1,Fan2,
J11,Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical,1,Fan3,
J12,Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical,1,Fan4,
J13,Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical,1,HV+ Connector,
J14,Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical,1,HV- Connector,
J15,Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical,1,Array Connector,
J17,Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical,1,Fan5,
J18,Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical,1,Strobe_Conn,
J19,PinHeader_2x04_P2.54mm_Vertical,1,ADC SPI,
J2,Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical,1,CarPowerConnector,
"J20, J4",PinHeader_2x04_P2.54mm_Vertical,2,Fan I2C,
J21,Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical,1,Segment1 Connector,
J22,Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical,1,Segment2 Connector,
J3,Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical,1,CANconn,
J5,Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical,1,CANconn2,
J6,Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical,1,I-CanConn,
J8,Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical,1,E-STOP,
J9,Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical,1,Fan1,
JP1,PinHeader_1x02_P2.54mm_Vertical,1,E-Stop Bypass,
"Q1, Q10, Q11, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9",SOT-23,11,IRLML0030,
"R1, R10, R12, R19, R26, R33, R40, R47, R50, R57, R58, R59, R60, R61, R63, R65, R8",0805,17,100k,
"R11, R14, R21, R28, R3, R35, R42, R49, R52, R67, R9",0805,11,1k,
"R13, R2, R20, R27, R34, R41, R48, R51, R66",0805,9,10k,
"R15, R22, R29, R36, R4, R43, R53, R68",2512,8,2.8m,
"R16, R17, R23, R24, R30, R31, R37, R38, R44, R45, R5, R54, R55, R6, R69, R70",0805,16,10,
"R18, R25, R32, R39, R46, R56, R7, R71",0805,8,1,
R62,0805,1,33k,
R64,0805,1,15k,
U10,QFN16_4x4MC_MCH,1,EMC2305-1-AP-TR,
"U11, U3, U4, U5, U6, U7, U8, U9",SOT-23-5(movedsilk),8,INA180A2,
U2,WQFN16_RTE_TEX,1,TLA2518IRTER,

## KiCad design BPS-LeaderDaughter.kicad_pcb

Board: 2 copper layers, 50.0 x 130.0 mm, 94 parts (62 on the bottom side), 53 nets.

Parts:
C1: 1uF; C_0805_2012Metric
D1, D3, D6, D9: Green; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2, D5, D8: BAS70-04; SOT-23
D4, D7, D10, D11, D13, D15, D17: 1N4448W; D_SOD-123
D12, D14, D16, D18: 3.3V; D_SOD-323
IC1: ADT7470ARQZ-REEL7; QSOP-16_3.9x4.9mm_P0.635mm
J1, J2: DaughterConnector; Molex_53307-2071
J3: ErrorLightConn; Molex_MicroFit3.0_1x2xP3.00mm_PolarizingPeg_Vertical
J4, J5, J6, J7, J9, J10, J11, J12: Conn_01x04; Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical
J8: Conn_01x03; Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8: Termination Resistors; PinHeader_1x02_P2.54mm_Vertical
LOGO1: Dr. Hallock; Hallock_Image_Tiny
LOGO2: UTSVT Logo; UTSVT_Logo_Symbol
MH1, MH2, MH3, MH4, MH5, MH6: M.3; MountingHole_3mm
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BUK9M23-80E; LFPAK33
R1, R5, R9, R13: 1k; R_0805_2012Metric
R2, R7, R11, R15, R22, R24, R27, R29, R32, R34, R37, R39: 10k; R_0805_2012Metric
R3, R6, R10, R14, R16, R18, R20, R21, R25, R26, R30, R31, R35, R36: 100k; R_0805_2012Metric
R17, R19: 600; R_0805_2012Metric
R23, R28, R33, R38: 20k; R_0805_2012Metric
U1, U2: EL3H7; SOP-4_4.4x2.6mm_P1.27mm

Connections:
+3.3V: C1.1, D2.2, D5.2, D8.2, IC1.3 (VCC), IC1.13 (~FULL_SPEED/TMP_START), J1.9, J1.11, J2.17, J2.18, J2.19, J2.20, R20.1, R21.1, R25.1, R26.1, R30.1, R31.1, R35.1, R36.1, U1.4, U2.4
+12V: D4.1 (K), D7.1 (K), D10.1 (K), D11.1 (K), D13.1 (K), D15.1 (K), D17.1 (K), J1.1, J1.2, J3.1, J4.1, J5.1, J6.1, J7.1, J9.2, J10.2, J11.2, J12.2, R2.1, R7.1, R11.1, R15.1, R22.1, R27.1, R32.1, R37.1
/Arr_IG: J2.15, R18.2, U2.3
/Array Contactor Driver/CONTACTOR_V-: D9.1 (K), D10.2 (A), J7.2, Q4.5 (D)
/Array_EN: J1.12, R13.1
/Array_Sense: D8.3, J1.10, J7.4
/Fan Control/Fan_PWM1/Fan_-: J9.1, Q5.5 (D)
/Fan Control/Fan_PWM1/TACH_IN: J9.3, R22.2, R23.1
/Fan Control/Fan_PWM2/Fan_-: J10.1, Q6.5 (D)
/Fan Control/Fan_PWM2/TACH_IN: J10.3, R27.2, R28.1
/Fan Control/Fan_PWM3/Fan_-: J11.1, Q7.5 (D)
/Fan Control/Fan_PWM3/TACH_IN: J11.3, R32.2, R33.1
/Fan Control/Fan_PWM4/Fan_-: J12.1, Q8.5 (D)
/Fan Control/Fan_PWM4/TACH_IN: J12.3, R37.2, R38.1
/Fan Control/ORION_PWM: J4.2, JP1.2 (B), JP2.2 (B), JP3.2 (B), JP4.2 (B)
/Fan Control/PWM1: IC1.15 (PWM1), J9.4, JP1.1 (A), JP5.1 (A), R20.2
/Fan Control/PWM2: IC1.5 (PWM2), J10.4, JP2.1 (A), JP6.1 (A), R25.2
/Fan Control/PWM3: IC1.8 (PWM3), J11.4, JP3.1 (A), JP7.1 (A), R30.2
/Fan Control/PWM4: IC1.10 (PWM4), J12.4, JP4.1 (A), JP8.1 (A), R35.2
/Fan Control/TACH1: D12.1 (K), IC1.6 (TACH1), J4.3, R23.2, R24.1
/Fan Control/TACH2: D14.1 (K), IC1.7 (TACH2), R28.2, R29.1
/Fan Control/TACH3: D16.1 (K), IC1.4 (TACH3), R33.2, R34.1
/Fan Control/TACH4: D18.1 (K), IC1.9 (TACH4), R38.2, R39.1
/Fault: J1.8, R1.1
/HV+ Contactor Driver/CONTACTOR_V-: D3.1 (K), D4.2 (A), J5.2, Q2.5 (D)
/HV+_EN: J1.7, R5.1
/HV+_Sense: D2.3, J1.5, J5.4
/HV- Contactor Driver/CONTACTOR_V-: D6.1 (K), D7.2 (A), J6.2, Q3.5 (D)
/HV-_EN: J2.16, R9.1
/HV-_Sense: D5.3, J2.14, J6.4
/Motor_IG: J2.13, R16.2, U1.3
/SCL: IC1.1 (SCL), J1.15
/SDA: IC1.16 (SDA), J1.13
/Strobe Light/Strobe_-: D1.1 (K), J3.2, Q1.5 (D)
/~SMBALERT: IC1.14 (~SMBALERT), J1.14
GND: C1.2, D2.1, D5.1, D8.1, D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), IC1.2 (GND), J1.3, J1.4, J1.6, J1.16, J1.17, J1.18, J2.1, J2.2, J2.3, J2.4, J2.10, J2.12, J4.4, J5.3, J6.3, J7.3, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.1 (S), Q8.2 (S), Q8.3 (S), R3.2, R6.2, R10.2, R14.2, R16.1, R18.1, R24.2, R29.2, R34.2, R39.2
GND1: J8.3, U1.2, U2.2
unnamed: D1.2 (A), R2.2
unnamed: D3.2 (A), R7.2
unnamed: D6.2 (A), R11.2
unnamed: D9.2 (A), R15.2
unnamed: J8.1, R17.2
unnamed: J8.2, R19.2
unnamed: JP5.2 (B), Q5.4 (G), R21.2
unnamed: JP6.2 (B), Q6.4 (G), R26.2
unnamed: JP7.2 (B), Q7.4 (G), R31.2
unnamed: JP8.2 (B), Q8.4 (G), R36.2
unnamed: Q1.4 (G), R1.2, R3.1
unnamed: Q2.4 (G), R5.2, R6.1
unnamed: Q3.4 (G), R9.2, R10.1
unnamed: Q4.4 (G), R13.2, R14.1
unnamed: R17.1, U1.1
unnamed: R19.1, U2.1

File BOM/BPS-LeaderDaughterBOM.xlsx:

Reference | Value | Footprint | P/N | Qty
C1 | 1uF | Capacitor_SMD:C_0805_2012Metric | C0805C105K5PACTU | 1
D1, D3, D6, D9 | Green | LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder | APTD2012LCGCK | 4
D2, D5, D8 | BAS70-04 | Package_TO_SOT_SMD:SOT-23 | BAS70-04 | 3
D4, D7, D10, D11, D13, D15, D17 | 1N4448W | Diode_SMD:D_SOD-123 | 1N4448W | 7
D12, D14, D16, D18 | 3.3V | Diode_SMD:D_SOD-323 | BZT52B3V3 | 4
IC1 | ADT7470ARQZ-REEL7 | Package_SO:QSOP-16_3.9x4.9mm_P0.635mm | ADT7470 | 1
J1, J2 | DaughterConnector | UTSVT_Connectors:Molex_53307-2071 | 53307-2071 | 2
J3 | ErrorLightConn | UTSVT_Connectors:Molex_MicroFit3.0_1x2xP3.00mm_PolarizingPeg_Vertical | 43650-0215 | 1
J4-J7, J9-J12 | Conn_01x04 | UTSVT_Connectors:Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical | 436500244 | 8
J8 | Conn_01x03 | Connector_Molex:Molex_Micro-Fit_3.0_43650-0315_1x03_P3.00mm_Vertical | 436500315 | 1
Q1-Q8 | BUK9M23-80E | Package_TO_SOT_SMD:LFPAK33 | BUK9M23-80E | 8
R1, R5, R9, R13 | 1k | Resistor_SMD:R_0805_2012Metric | CRCW08051K00FKEAC | 4
R2, R7, R11, R15, R22, R24, R27, R29, R32, R34, R37, R39 | 10k | Resistor_SMD:R_0805_2012Metric | CRCW080510K0FKEAC | 12
R3, R6, R10, R14, R16, R18, R20, R21, R25, R26, R30, R31, R35, R36 | 100k | Resistor_SMD:R_0805_2012Metric | CRCW0805100KFKEAC | 14
R17, R19 | 600 | Resistor_SMD:R_0805_2012Metric | CRCW0805600RFKEAHP | 2
R23, R28, R33, R38 | 20k | Resistor_SMD:R_0805_2012Metric | CRCW080522K1FKEA | 4
U1, U2 | EL3H7 | Package_SO:SOP-4_4.4x2.6mm_P1.27mm | EL3H7(D)(TA)-VG | 2
